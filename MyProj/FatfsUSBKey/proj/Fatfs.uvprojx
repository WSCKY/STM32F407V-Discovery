# Keil uVision project Fatfs.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fatfs
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, USE_USB_OTG_FS, STM32F4XX, __FPU_PRESENT=1
  c misc: --c99
  c include: ..\inc;..\main;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\STM32F4xx;..\..\Utilities\STM32F4-Discovery;..\..\Utilities\fat_fs\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../main/: startup_stm32f4xx.s
  group main
    ../main/: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../src/: usb_bsp.c usbh_usr.c
  group board
    ../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group periph
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group USB_OTG_Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST_Library
    ../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group FAT_FS
    ../../Utilities/fat_fs/src/: fattime.c ff.c
software components: CMSIS:CORE 4.1.0
